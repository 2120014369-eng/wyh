# Keil uVision project neo.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: neo +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Lib\inc;.\Startup;D:\MDK\ARM\PACK\ARM\CMSIS\5.8.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c myusart.c mycar.c ultrasonic.c track.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s system_stm32f10x.c
  group StdPeriph
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_exti.c
software components: CMSIS:CORE 5.5.0, Device:GPIO 1.3
